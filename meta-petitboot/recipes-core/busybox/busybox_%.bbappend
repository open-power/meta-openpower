FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://petitboot.cfg"
