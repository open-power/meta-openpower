EXTRA_OECONF:append:petitroot = " --enable-intf-usb"
