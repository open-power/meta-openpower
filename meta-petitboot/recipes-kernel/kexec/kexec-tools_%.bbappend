RPROVIDES:kexec += "virtual-kexec"
