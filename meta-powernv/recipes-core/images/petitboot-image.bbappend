PETITBOOT_IMAGE_EXTRA_INSTALL += "\
    gard \
    pflash \
"
